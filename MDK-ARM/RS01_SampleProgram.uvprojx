# Keil uVision project RS01_SampleProgram.uvprojx, settings and files
target RS01_SampleProgram (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: RS01_SampleProgram +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User/RS;../User/DEBUG;../User/Jetson
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group User
    ../User/DEBUG/: debugc.c debugc.h
    ../User/RS/: Robstride01.cpp Robstride.h
    ../User/Jetson/: jetson_comm.c jetson_comm.h
software components: CMSIS:CORE 4.3.0
